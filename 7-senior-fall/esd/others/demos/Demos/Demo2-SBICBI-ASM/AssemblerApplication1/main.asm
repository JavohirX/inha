;
; AssemblerApplication1.asm
; Author : hjeong
;

.ORG 0
	LDI R16, HIGH(RAMEND)
	OUT SPH, R16
	LDI R16, LOW(RAMEND)
	OUT SPL, R16

MAIN:
	SBI DDRB, 5
L3: SBI PORTB,5
	CALL DELAY
	CBI PORTB,5
	CALL DELAY
	RJMP L3

DELAY:
	LDI R20, 255
D0: LDI R21, 255
	D1: LDI R22, 250
		D2: NOP
			NOP
			DEC R22
			BRNE D2
		DEC R21
		BRNE D1
	DEC R20
	BRNE D0
	RET